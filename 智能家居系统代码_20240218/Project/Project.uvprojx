# Keil uVision project Project.uvprojx, settings and files
target PROJECT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Libraries\FWlib\src;..\User;..\SYSTEM\usart;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\BEEP;..\HARDWARE\FAN;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\DHT11;..\SYSTEM\sys;..\HARDWARE\LED;..\HARDWARE\MOTOR;..\HARDWARE\Gizwits;..\HARDWARE\Utils;..\HARDWARE\TIME;..\HARDWARE\BMP280;..\HARDWARE\STMFLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart2.c usart1.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/TIME/: timer.c
    ../HARDWARE/BMP280/: bmp280.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group DOC
    ../Doc/: readme.txt
  group Gizwits
    ../HARDWARE/Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../HARDWARE/Utils/: common.c dataPointTools.c ringbuffer.c
